FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://linux_input_c.patch"