RDEPENDS_${PN}-bin_remove = "perl"
