include cups-filters.inc

#SRC_URI = "https://github.com/Distrotech/${PN}/archive/release-1-5-0.tar.gz"
LIC_FILES_CHKSUM = "file://COPYING;md5=516215fd57564996d70327db19b368ff"
SRC_URI[md5sum] = "d23afd73d1c4af984488378bdeb7cde9"
SRC_URI[sha256sum] = "397ba572d32b269ac70827f5c0f77878f857d5ab39de3fd0e801a00663037148"
