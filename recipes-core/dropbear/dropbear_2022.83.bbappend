EXTRA_OECONF += "--disable-wtmp --disable-lastlog"
