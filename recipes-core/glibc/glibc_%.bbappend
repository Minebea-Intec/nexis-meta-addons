EXTRA_OECONF += "--enable-obsolete-nsl"
